options:
  parameters:
    generate_options: qt_gui
    id: rfid_serial
    output_language: python
    realtime_scheduling: '1'
    run_command: sudo {python} -u {filename}
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '910000000'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '[1] * 25'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wuyun/Code/USRP/gr-rfid/misc/data/file_source_test
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: adc_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: n_taps
    type: ccf
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: '"reader"'
    size: '1024'
    srate: adc_rate/decim
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: '"source"'
    size: '1024'
    srate: adc_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: dac_rate
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_serial_write_0
  id: rfid_serial_write
  parameters:
    serial_port: '1'
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}

connections:
- [blocks_complex_to_float_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_time_sink_x_0_1_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', rfid_serial_write_0, '1']
- [blocks_null_source_0, '0', rfid_serial_write_0, '0']
- [blocks_null_source_0_0, '0', rfid_serial_write_0, '2']
- [blocks_throttle_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_reader_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_null_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
